# Keil uVision project project.uvprojx, settings and files
target stm32f103 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Bsp;..\Main;..\User;..\Libraries\inc;..\Libraries\CMSIS\Core3;..\Libraries\CMSIS\StartUp\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../Main/: main.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp
    ../Bsp/: bsp.c bsp.h bsp_clock.c bsp_clock.h bsp_gpio.c bsp_gpio.h bsp232.c bsp232.h
  group user
    ../User/: rs232.c rs232.h port.c port.h common.c common.h sys.c timer.c delay.c exit.c
  group com3
    ../Libraries/CMSIS/Core3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/StartUp/arm/: startup_stm32f10x_md.s
  group libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 4.1.0
